LICENSE="CLOSED"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
